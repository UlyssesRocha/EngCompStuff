# Keil uVision project ArmCTP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: ArmCTP
  c flags: Optim=1
  group Source Group 1
    C:/Users/PC/Desktop/: final.c
